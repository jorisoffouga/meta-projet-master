OS_RELEASE_FIELDS_append = " PROJET_MASTER_PRODUCT"
PROJET_MASTER_PRODUCT = "Projet Connect"
